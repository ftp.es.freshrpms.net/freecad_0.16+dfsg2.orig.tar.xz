*Node, NSET=Nall
1, 0, 0, 0
2, 0, 0, 10
3, 0, 10, 0
4, 0, 10, 10
5, 10, 0, 0
6, 10, 0, 10
7, 10, 10, 0
8, 10, 10, 10
9, 0, 0, 5
10, 0, 0, 2.5
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*Element, TYPE=C3D10, ELSET=Eall
633, 95, 98, 47, 196, 103, 197, 198, 200, 199, 201,
634, 147, 121, 145, 196, 203, 202, 161, 205, 204, 206,
635, 73, 70, 27, 121, 84, 80, 83, 208, 207, 136,
636, 72, 170, 30, 171, 209, 187, 75, 210, 181, 194,
637, 9, 98, 47, 95, 101, 197, 54, 102, 103, 198,
638, 172, 70, 30, 71, 211, 78, 186, 212, 93, 91,
639, 170, 99, 36, 174, 213, 119, 184, 191, 214, 190,
640, 12, 47, 149, 145, 57, 215, 150, 152, 216, 155,
641, 70, 27, 123, 72, 80, 143, 217, 79, 77, 218,
642, 39, 147, 121, 145, 160, 203, 132, 159, 161, 202,
643, 70, 120, 121, 196, 219, 134, 207, 221, 220, 204,
644, 70, 172, 170, 196, 211, 183, 222, 221, 223, 224,
645, 95, 99, 170, 195, 104, 213, 225, 227, 226, 228,
646, 145, 45, 47, 196, 229, 56, 216, 206, 230, 201,
647, 70, 123, 120, 195, 217, 126, 219, 232, 231, 233,
648, 47, 45, 95, 196, 56, 234, 198, 201, 230, 200,
649, 121, 120, 145, 196, 134, 235, 202, 204, 220, 206,
650, 145, 39, 120, 121, 159, 133, 235, 202, 132, 134,
651, 70, 120, 27, 121, 219, 137, 80, 207, 134, 136,
652, 9, 47, 45, 95, 54, 56, 52, 102, 198, 234,
653, 70, 27, 120, 123, 80, 137, 219, 217, 143, 126,
654, 45, 47, 12, 145, 56, 57, 58, 229, 216, 152,
655, 170, 95, 36, 99, 225, 109, 184, 213, 104, 119,
656, 195, 45, 145, 196, 237, 229, 236, 238, 230, 206,
657, 95, 45, 195, 196, 234, 237, 227, 200, 230, 238,
658, 170, 95, 195, 196, 225, 227, 228, 224, 200, 238,
659, 70, 170, 195, 196, 222, 228, 232, 221, 224, 238,
660, 195, 120, 70, 196, 233, 219, 232, 238, 220, 221,
661, 145, 120, 195, 196, 235, 233, 236, 206, 220, 238,
662, 74, 24, 148, 196, 86, 165, 239, 241, 240, 242,
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

***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam)
** written by write_element_sets_material_and_femelement_type function
*ELSET,ELSET=MechanicalMaterialSolid
Eall

***********************************************************
** Node set for fixed constraint
** written by write_node_sets_constraints_fixed function
*NSET,NSET=FemConstraintFixed
1,
2,
3,
4,
9,
10,
11,
12,
13,
14,
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
***********************************************************
** Node sets for prescribed displacement constraint
** written by write_node_sets_constraints_displacement function

***********************************************************
** Materials
** written by write_materials function
** Young's modulus unit is MPa = N/mm2
**FreeCAD material name: Steel-Generic
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
200000 ,  0.300
*DENSITY
7.900e-09,

***********************************************************
** Sections
** written by write_femelementsets function
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** One step is needed to calculate the mechanical analysis of FreeCAD
** loads are applied quasi-static, means without involving the time dimension
** written by write_step_begin function
*STEP
*STATIC

***********************************************************
** Constaints
** written by write_constraints_fixed function
*BOUNDARY
FemConstraintFixed,1
FemConstraintFixed,2
FemConstraintFixed,3


***********************************************************
** Displacement constraint applied
** written by write_constraints_displacement function


***********************************************************
** Frequency analysis
** written by write_frequency function
*FREQUENCY
10,0.0,1000000.0

***********************************************************
** Outputs --> frd file
** written by write_outputs_types function
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
*NODE PRINT , NSET=Nall
U
*EL PRINT , ELSET=Eall
S

***********************************************************
** written by write_step_end function
*END STEP

***********************************************************
** CalculiX Input file
** written by write_footer function
**   written by    --> FreeCAD 0.16.5838 +1 (Git)
**   written on    --> Mon Oct 26 18:34:01 2015
**   file name     -->
**   analysis name --> MechanicalAnalysis
**
**
**
**   Units
**
**   Geometry (mesh data)        --> mm
**   Materials (Young's modulus) --> N/mm2 = MPa
**   Loads (nodal loads)         --> N
**
